# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-STM32U385RG-Q (6190000::V6.19::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U385xx,USE_HAL_DRIVER
  c include: ..\..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include;..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32U3xx_Nucleo;..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core;..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32U3;..\..\..\..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../../Src/: main.c stm32u3xx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Source/Templates/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_comp.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_exti.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32U3/: flash_interface.c
software components: CMSIS:CORE 5.6.0
