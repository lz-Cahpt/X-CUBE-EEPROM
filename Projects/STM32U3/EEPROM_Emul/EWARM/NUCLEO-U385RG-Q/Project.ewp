# IAR project Project.ewp, settings and files
configuration NUCLEO-STM32U385RG-Q (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U385xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32U3xx_Nucleo; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32U3; ..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NUCLEO-STM32U385RG-Q.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../../Src/: main.c stm32u3xx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Source/Templates/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_comp.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32U3/: flash_interface.c
