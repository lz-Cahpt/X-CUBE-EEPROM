# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-H563ZI (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.0.0.5
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: NUCLEO-H563ZI +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx,USE_FULL_LL_DRIVER,FLASH_LINES_128B
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32H5xx_Nucleo;../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32H5;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_ll_crc.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_rcc.c stm32h5xx_ll_utils.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32H5/: flash_interface.c
target NUCLEO-H563ZI_EDATA_ENABLED (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.0.0.5
  cpu: as above
  output: NUCLEO-H563ZI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx,USE_FULL_LL_DRIVER,EDATA_ENABLED
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
software components: CMSIS:CORE 5.6.0
