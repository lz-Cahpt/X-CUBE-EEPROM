# IAR project Project.ewp, settings and files
configuration NUCLEO-H563ZI (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx; USE_FULL_LL_DRIVER; FLASH_LINES_128B
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32H5xx_Nucleo; ..\..\..\..\Middlewares\ST\EEPROM_Emul\Core; ..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32H5; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NUCLEO-H563ZI.hex
  ILINK.IlinkOutputFile: NUCLEO-H563ZI.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NUCLEO-H563ZI_EDATA_ENABLED (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx; USE_FULL_LL_DRIVER; EDATA_ENABLED
  ICCARM.CCOptLevel: 0
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_ll_crc.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_rcc.c stm32h5xx_ll_utils.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32H5/: flash_interface.c
