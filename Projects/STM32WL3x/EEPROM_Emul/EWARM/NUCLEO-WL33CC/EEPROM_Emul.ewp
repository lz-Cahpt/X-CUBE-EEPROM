# IAR project EEPROM_Emul.ewp, settings and files
configuration NUCLEO-WL33CC (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL33CC ST STM32WL33CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WL3xx; CORE_CM0PLUS; STM32WL3XX
  ICCARM.CCIncludePath2: ../../Inc; ../../../../../Drivers/STM32WL3x_HAL_Driver/Inc; ../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32WL3x/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/STM32WL3x-Nucleo; ../../../../../Middlewares/ST/EEPROM_Emul/Core; ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WL3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EEPROM_Emul.bin
  ILINK.IlinkOutputFile: EEPROM_Emul.out
  ILINK.IlinkIcfFile: stm32wl3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3xx.s
  group Application/User
    ../../Src/: main.c stm32wl3x_hal_msp.c stm32wl3x_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32WL3x-Nucleo/: stm32wl3x_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32wl3x.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal.c stm32wl3x_hal_cortex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WL3/: flash_interface.c
