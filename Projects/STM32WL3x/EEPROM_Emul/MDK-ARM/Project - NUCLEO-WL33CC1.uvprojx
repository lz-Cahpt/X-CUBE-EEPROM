# Keil uVision project Project - NUCLEO-WL33CC1.uvprojx, settings and files
target Project - NUCLEO-WL33CC1 (6190000::V6.19::ARMCLANG)
  device: STM32WL33CCVx STMicroelectronics
  pack: Keil.STM32WL3x_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x10040000-0x1007FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: GPIO_IOToggle +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL3xx,CORE_CM0PLUS,STM32WL3XX
  c misc: -fshort-enums
  c include: ../Inc;..\..\..\..\Drivers\STM32WL3x_HAL_Driver\Inc;..\..\..\..\Drivers\STM32WL3x_HAL_Driver\Inc\Legacy;..\..\..\..\Drivers\CMSIS\Device\ST\STM32WL3X\Include;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\BSP\STM32WL3x-Nucleo;..\..\..\..\Middlewares\ST\EEPROM_Emul\Core;..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32WL3
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32wl3xx_flash.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L1215
  group Application/MDK-ARM
    ./: startup_stm32wl3xx.s
  group Application/User
    ../Src/: main.c stm32wl3x_it.c stm32wl3x_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3x-Nucleo
    ../../../../Drivers/BSP/STM32WL3x-Nucleo/: stm32wl3x_nucleo.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_cortex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
  group Middlewares/ST/EEPROM_Emul/Core
    ../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/ST/EEPROM_Emul/Porting
    ../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32WL3/: flash_interface.c
software components: CMSIS:CORE 5.6.0
