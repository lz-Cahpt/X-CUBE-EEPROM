# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-C031C6 (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IROM(0x08000000-0x8007FFF) IRAM(0x20000000-0x20002FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C031xx
  c include: ../../Inc;../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STM32C0xx_Nucleo;../../../../../Middlewares/ST/EEPROM_Emul/Core;../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32C0
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/MDK-ARM
    ./: startup_stm32c031xx.s
  group Application/User
    ../../Src/: main.c stm32c0xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32C0xx_Nucleo
    ../../../../../Drivers/BSP/STM32C0xx_Nucleo/: stm32c0xx_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32c0xx.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_exti.c
  group Middlewares/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32C0/: flash_interface.c
software components: CMSIS:CORE 4.3.0
