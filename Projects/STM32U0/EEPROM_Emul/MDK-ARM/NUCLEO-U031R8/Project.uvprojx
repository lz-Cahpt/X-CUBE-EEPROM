# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U031R8 (6190000::V6.19::ARMCLANG)
  device: STM32U031R8Tx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IRAM2(0x20002000,0x1000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO-U031R8 +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32U031xx,
  c include: ..\..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include;..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32U0xx_Nucleo;..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core;..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32U0;..\..\..\..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32u031xx.s
  group Application/User
    ../../Src/: main.c stm32u0xx_it.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Source/Templates/: system_stm32u0xx.c
  group Drivers/BSP/STM32U0xx_Nucleo
    ../../../../../Drivers/BSP/STM32U0xx_Nucleo/: stm32u0xx_nucleo.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_ll_crc.c stm32u0xx_ll_exti.c stm32u0xx_ll_gpio.c stm32u0xx_ll_rcc.c stm32u0xx_ll_utils.c
  group Middlewares/EEPROM_Emul/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/EEPROM_Emul/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32U0/: flash_interface.c
  group Doc
    ../../: readme.txt
software components: CMSIS:CORE 5.6.0
